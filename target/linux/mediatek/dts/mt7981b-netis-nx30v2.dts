/* USB support fix for Netcore N30 Pro / netis NX30 V2:
 * - add explicit VBUS fixed regulator (GPIO23, active-high, boot-on)
 * - enable USB PHY (u2port0/u3port0) and xHCI controller
 * Fixes: USB ports get no 5V VBUS power, devices never enumerate.
 */
/ {
	usb_vbus: regulator-usb {
		compatible = "regulator-fixed";
		regulator-name = "usb-vbus";
		regulator-type = <1>; /* REGULATOR_VOLTAGE */
		regulator-min-microvolt = <5000000>;
		regulator-max-microvolt = <5000000>;
		gpios = <&pio 23 GPIO_ACTIVE_HIGH>;
		enable-active-high;
		regulator-boot-on;
	};
};

&usb_phy {
	status = "okay";
};

&u2port0 {
	status = "okay";
};

&u3port0 {
	status = "okay";
};

&xhci {
	vbus-supply = <&usb_vbus>;
	status = "okay";
};
OLOR_ID_BLUE>;
			function = LED_FUNCTION_WPS;
			gpios = <&pio 5 GPIO_ACTIVE_LOW>;
		};

		wifi2g {
			color = <LED_COLOR_ID_BLUE>;
			function = LED_FUNCTION_WLAN_2GHZ;
			gpios = <&pio 34 GPIO_ACTIVE_LOW>;
			linux,default-trigger = "phy0tpt";
		};

		wifi5g {
			color = <LED_COLOR_ID_BLUE>;
			function = LED_FUNCTION_WLAN_5GHZ;
			gpios = <&pio 35 GPIO_ACTIVE_LOW>;
			linux,default-trigger = "phy1tpt";
		};

		wan {
			color = <LED_COLOR_ID_BLUE>;
			function = LED_FUNCTION_WAN;
			gpios = <&pio 8 GPIO_ACTIVE_LOW>;
		};
	};
};

&switch {
	ports {
		port@0 {
			reg = <1>;
			label = "lan1";
		};

		port@1 {
			reg = <2>;
			label = "lan2";
		};

		port@2 {
			reg = <3>;
			label = "lan3";
		};
	};
};

